# Keil uVision project bk3432.uvproj, settings and files
target BK3432_app (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3432_ble_app
  AfterMake: fromelf --bin --output .\output\app\bk3432_ble_app.bin .\obj\bk3432_ble_app.axf
  AfterMake: .\output\encrypt_app.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --c99
  c include: .\config;.\app;..\..\libs;..\..\sdk\plactform\core_modules\src;..\..\sdk\plactform\arch;..\..\sdk\plactform\arch\compiler;..\..\sdk\plactform\arch\ll;..\..\sdk\plactform\core_modules\common\api;..\..\sdk\plactform\arch\boot;..\..\sdk\plactform\core_modules\dbg\api;..\..\sdk\plactform\core_modules\rf\api;..\..\sdk\plactform\core_modules\ecc_p256\api;..\..\sdk\plactform\arch\main;..\..\sdk\plactform\core_modules\util;..\..\sdk\plactform\driver\pwm;..\..\sdk\plactform\driver\adc;..\..\sdk\plactform\driver\audio;..\..\sdk\plactform\driver\wdt;..\..\sdk\plactform\driver\rtc;..\..\sdk\plactform\driver\i2c;..\..\sdk\plactform\driver\utc;..\..\sdk\plactform\driver\ir;..\..\sdk\plactform\driver\spi;..\..\sdk\plactform\driver\plf;..\..\sdk\plactform\driver\counter;..\..\sdk\plactform\driver\gpio;..\..\sdk\plactform\driver\intcntl;..\..\sdk\plactform\driver\icu;..\..\sdk\plactform\driver\intc;..\..\sdk\plactform\driver\flash;..\..\sdk\plactform\driver\timer;..\..\sdk\plactform\driver\reg;..\..\sdk\plactform\driver\uart;..\..\sdk\plactform\driver\emi;..\..\sdk\ble_stack\com\rwble;..\..\sdk\ble_stack\com\rwble_hl;..\..\sdk\ble_stack\com\rwble;..\..\sdk\ble_stack\com\rwip\api;..\..\sdk\ble_stack\com\rwble_hl;..\..\sdk\ble_stack\src;..\..\sdk\plactform\reg;..\..\sdk\plactform\driver\syscntl;..\..\sdk\plactform\rom\hci;..\..\sdk\plactform\core_modules\ecc_p256\api;..\..\sdk\ble_stack\inc;..\..\sdk\ble_stack\inc\hci;..\..\sdk\ble_stack\inc\h4tl;..\..\sdk\ble_stack\inc\ke;..\..\sdk\ble_stack\inc\nvds;..\..\sdk\ble_stack\inc\ea;..\..\sdk\ble_stack\inc\em;..\..\sdk\ble_stack\inc\ahi;..\..\sdk\ble_stack\inc\ble\hl\gap\gapc;..\..\sdk\ble_stack\inc\ble\hl\gap\gapm;..\..\sdk\ble_stack\inc\ble\hl\gap\smpc;..\..\sdk\ble_stack\inc\ble\hl\gap\smpm;..\..\sdk\ble_stack\inc\ble\hl\gatt\attc;..\..\sdk\ble_stack\inc\ble\hl\gatt\attm;..\..\sdk\ble_stack\inc\ble\hl\gatt\atts;..\..\sdk\ble_stack\inc\ble\hl\gatt\gattc;..\..\sdk\ble_stack\inc\ble\hl\gatt\gattm;..\..\sdk\ble_stack\inc\ble\hl\l2c\l2cc;..\..\sdk\ble_stack\inc\ble\hl\l2c\l2cm;..\..\sdk\ble_stack\inc\ble\ll\em;..\..\sdk\ble_stack\inc\ble\ll\llc;..\..\sdk\ble_stack\inc\ble\ll\lld;..\..\sdk\ble_stack\inc\ble\ll\llm;..\..\sdk\ble_stack\com\rwip\api;..\..\sdk\ble_stack\inc\ble\hl\gap;..\..\sdk\ble_stack\inc\ble\hl\gatt;..\..\sdk\ble_stack\com\prf;..\..\sdk\ble_stack\com\profiles\dis\diss\src;..\..\sdk\ble_stack\com\profiles\bas\bass\src;..\..\sdk\ble_stack\com\profiles\ancs\ancsc\api;..\..\sdk\ble_stack\com\profiles\ancs\ancsc\src;..\..\sdk\ble_stack\com\profiles\ancs;..\..\sdk\ble_stack\com\profiles\FCC0\api;..\..\sdk\ble_stack\com\profiles\FCC0\src;..\..\sdk\ble_stack\com\profiles\FCC0\util;..\..\sdk\ble_stack\com\profiles\FEE0\api;..\..\sdk\ble_stack\com\profiles\FEE0\src;..\..\sdk\ble_stack\com\profiles\hogp;..\..\sdk\ble_stack\com\profiles\hogp\hogpd\api;..\..\sdk\ble_stack\com\profiles\hogp\hogpd\src;..\..\libs;..\..\sdk\ble_stack\com\profiles\wechat\api;..\..\sdk\ble_stack\com\profiles\wechat\src;.\wechat;..\..\sdk\ble_stack\com\profiles\bas\bass;..\..\sdk\ble_stack\com\profiles\bas\bass\api;..\..\sdk\ble_stack\com\profiles\dis\diss;..\..\sdk\ble_stack\com\profiles\dis\diss\api;..\..\sdk\ble_stack\com\profiles\FFF0\api;..\..\sdk\ble_stack\com\profiles\FFF0;..\..\sdk\ble_stack\com\profiles\oad\api;..\..\libs\AT_Module;..\..\libs\drv;..\..\libs\Password;..\..\libs\Tools;..\..\sdk\plactform\driver\uart2
  asm include: .\src\plf\refip\src\arch\ll
  library: MicroLIB
  scatter file: ..\..\sdk\project_files\link_app.txt
  link misc: --entry sys_Reset
  group System
    ./app/: arch_main.c
    ../../sdk/project_files/: stack_rom_symbol.txt
    ../../sdk/plactform/arch/boot/: boot_handlers.s boot_vectors.s
  group config
    ./config/: rwip_config.h rwprf_config.h user_config.h
  group ip
    ../../sdk/ble_stack/com/rwble_hl/: rwble_hl.c
    ../../sdk/ble_stack/com/rwble/: rwble.c
    ../../sdk/ble_stack/com/rwip/src/: rwip.c
  group driver
    ../../sdk/plactform/driver/emi/: emi.c
    ../../sdk/plactform/driver/flash/: flash.c
    ../../sdk/plactform/driver/gpio/: gpio.c
    ../../sdk/plactform/driver/icu/: icu.c
    ../../sdk/plactform/driver/intc/: intc.c
    ../../sdk/plactform/driver/pwm/: pwm.c pwm.h
    ../../sdk/plactform/driver/timer/: timer.c timer.h
    ../../sdk/plactform/driver/wdt/: wdt.c
    ../../sdk/plactform/driver/uart/: uart.c
    ../../sdk/plactform/core_modules/rf/src/: rf_xvr.c
    ../../sdk/plactform/driver/adc/: adc.c
    ../../sdk/plactform/driver/led/: led.c led.h
    ../../sdk/plactform/driver/uart2/: uart2.c uart2.h
  group profile
    ../../sdk/ble_stack/com/profiles/bas/bass/src/: bass.c bass.h bass_task.c
    ../../sdk/ble_stack/com/profiles/dis/diss/src/: diss.c diss.h diss_task.c
    ../../sdk/ble_stack/com/profiles/FFF0/src/: fff0s.c fff0s_task.c
    ../../sdk/ble_stack/com/profiles/oad/src/: oads.c oads_task.c
    ../../sdk/ble_stack/com/prf/: prf.c prf_utils.c
  group app
    ./app/: app.c app_batt.c app_dis.c app_fff0.c app_task.c app_oads.c app_profile_utils.c app_uart.c
  group libs
    ../../libs/: sys_manager.c
    ../../libs/Tools/: tools.c
    ../../libs/drv/: drv_charger.c drv_load.c drv_rgb.c drv_battery.c drv_battery.h app_motor.c app_motor.h drv_rgb.h
    ../../libs/AT_Module/: AT.c
